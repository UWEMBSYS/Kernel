# IAR project kernel.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\silver\Projects\EMBSYS\Kernel\inc; C:\Users\silver\Projects\EMBSYS\Kernel\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: kernel.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group inc
    ../inc/: clocks.h context.h CriticalRegion.h errors.h globals.h interrupts.h mutex.h nucleoboard.h pinmux.h stm32f401.h threads.h
    ../src/: config.h
  group src
    ../src/: clocks.c CriticalRegion.c globals.c interrupts.c main.c pinmux.c startup.s
